# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_CL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Utilities;.\Application\Include;.\Utilities\LED;.\Utilities\PWM;.\Utilities\TIMER1;.\Utilities\TIMER2;.\Utilities\USART;.\Utilities\AS5600;.\Utilities\I2C;.\Utilities\ADC;.\Utilities\TIMER3;..\..\..\foc_core\include\L1_Orchestration;..\..\..\foc_core\include\L2_Core;..\..\..\foc_core\include\L3_Hal;..\..\..\foc_core\include\LS_Config;..\..\..\foc_core\include;.\Utilities\AUXTIMER;.\Utilities\TIMER5
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ./Application/Source/: foc_platform_api.c gd32f30x_it.c main.c systick.c
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ./Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ./Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
  group Utilities
    ./Utilities/TIMER2/: timer2.c
    ./Utilities/TIMER1/: timer1.c
    ./Utilities/PWM/: pwm.c
    ./Utilities/LED/: LED.c
    ./Utilities/AS5600/: as5600.c
    ./Utilities/ADC/: adc.c
    ./Utilities/I2C/: i2c0.c
    ./Utilities/USART/: usart2.c usart0.c
    ./Utilities/TIMER3/: timer3.c
    ./Utilities/AUXTIMER/: auxtimer.c
    ./Utilities/TIMER5/: timer5.c
  group Foc
    ../../../foc_core/src/L1_Orchestration/: foc_app.c foc_app_event.c foc_output_mgr.c foc_indicator.c foc_init.c
    ../../../foc_core/src/L2_Core/Runtime/: foc_debug_stream.c foc_queue.c foc_task_scheduler.c
    ../../../foc_core/src/L2_Core/Protocol/: foc_protocol_handler.c foc_protocol_output.c foc_protocol_parser.c
    ../../../foc_core/src/L2_Core/Control/: foc_ctrl_actuation.c foc_ctrl_cfg.c foc_ctrl_compensation.c foc_ctrl_current_loop.c foc_ctrl_executor.c foc_ctrl_init.c foc_ctrl_outer_loop.c foc_ctrl_estim_hfi.c foc_ctrl_estim_smo.c foc_ctrl_source_mgr.c foc_ctrl_openloop.c foc_ctrl_sens_cogging_calib.c foc_ctrl_align.c foc_ctrl_acoustic.c foc_ctrl_injection.c
    ../../../foc_core/src/L3_Hal/: foc_math_transforms.c foc_sensor.c foc_svpwm.c foc_filter_math.c foc_codec.c foc_ringtone.c
target GD32F30X_XD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RK GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_XD
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Utilities;.\Application\Include;.\Utilities\LED;.\Utilities\PWM;.\Utilities\TIMER1;.\Utilities\TIMER2;.\Utilities\USART;.\Utilities\AS5600;.\Utilities\I2C;.\Utilities\ADC;.\Utilities\TIMER3;..\..\..\foc\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x18000
target GD32F30X_HD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: .\Firmware\CMSIS;.\Firmware\CMSIS\GD\GD32F30x\Include;.\Firmware\GD32F30x_standard_peripheral\Include;.\Utilities;.\Application\Include;.\Utilities\LED;.\Utilities\PWM;.\Utilities\TIMER1;.\Utilities\TIMER2;.\Utilities\USART;.\Utilities\AS5600;.\Utilities\I2C;.\Utilities\ADC;.\Utilities\TIMER3;..\..\..\foc_core\include;..\..\..\foc_core\include\L1_Orchestration;..\..\..\foc_core\include\L3_Hal;..\..\..\foc_core\include\LS_Config;..\..\..\foc_core\include\L2_Core\Protocol;..\..\..\foc_core\include\L2_Core\Control;..\..\..\foc_core\include\L2_Core\Runtime
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.2.0
